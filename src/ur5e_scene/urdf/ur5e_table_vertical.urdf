Commit message: bsll trsacking ddone

File: src/ur5e_scene/urdf/ur5e_table_vertical.urdf (robot description, URDF)
Before this commit: robot cu_ur5e, 25 links, 24 joints
Links:
- removed link arm_ee_adapter
Joints:
- removed joint arm_flange_to_adapter
